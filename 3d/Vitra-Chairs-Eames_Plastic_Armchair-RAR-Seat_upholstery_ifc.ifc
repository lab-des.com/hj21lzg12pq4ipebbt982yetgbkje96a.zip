Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: 0001
Time: 2023-05-16T14:48:08
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20200210_1400(x64) - Exporter 20.2.12.1 - Alternate UI 20.2.12.1
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Tue May 16 14:48:08 2023 * Host: DESKTOP-BQGE6H4 * Database: C:\Users\Avocado\AppData\Local\Temp\203940e8-027a-4771-a0dc-9c71a667b80d\bdf743e9-a45e-41c6-8031-74516a67867d\ifc * Database version: 5507 * Database creation date: Tue May 16 14:48:06 2023 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Tue May 16 14:48:06 2023 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Tue May 16 14:48:06 2023 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, 0001
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: 0001; Project Status: Project Status

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Pset_ProductRequirements - Category: Project Information
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: 0001; Project Status: Project Status

# IfcBuildingStorey: Level:8mm Head, Level 1
LongName: Level 1; Elevation: 0 mm
Other(Type) - Category: Levels; Family Name: Level
Identity Data(Type) - Type Name: 8mm Head
Pset_AirSideSystemInformation - Name: Level 1
Pset_ProductRequirements - Name: Level 1; Category: Levels
Constraints - Elevation: 0 mm
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Name: Level 1; Structural: no
Other - Category: Levels; Family: Level: 8mm Head; Family and Type: Level: 8mm Head; Type: Level: 8mm Head; Type Id: Level: 8mm Head
Constraints(Type) - Elevation Base: Project Base Point
Graphics(Type) - Color: 0; Line Pattern: Centre; Line Weight: 1; Symbol: M_Level Head - Circle: M_Level Head - Circle; Symbol at End 1 Default: no; Symbol at End 2 Default: yes

# IfcFurnishingElement: Eames Plastic Armchair RAR, with seat upholstery, Vitra-Chairs-Eames_Plastic_Armchair-RAR_rfa:Eames Plastic Armchair RAR, with seat upholstery:437736
In: Level 1
Type - Material: Legs Golden Maple, Chrome, Hopsak red cognac, Poppy red
Type - Constraints - Default Elevation: 0 mm
Type - Construction - full upholstery: no; Seat cushion: yes
Type - Dimensions - NominalDepth: 800 mm; NominalHeight: 720 mm; NominalLength: 630 mm
Type - General - Author: BIMStone; BIMObjectName: Vitra-Chairs-Eames_Plastic_Armchair-LAR_rfa; ManufacturerName: Vitra; ManufacturerURL: https://www.vitra.com/; NBSDescription: Domestic chairs; NBSReference: 45-35-20/365; ProductInformation: The Plastic Chairs number among the most well-known designs by Charles and Ray Eames. One model has always stood out in this large family of chairs: the Rocking Armchair Rod Base (RAR). Despite compact dimensions, it offers pleasant comfort even for taller users, and is also available with a seat cushion or full upholstery. The RAR is a fully-fledged armchair, whose iconic shape and rocker base on wooden runners adds a striking accent to any living room.; Revision: 0; Uniclass2: Pr_40_50_12_48; Uniclass2015Description: Easy chairs; Uniclass2015Reference: Pr_40_50_12_26; Version: 1; VersionDate: 05/04/2023
Type - Identity Data - Collection: Eames Plastic Armchair; Cost: 0; Description: The Plastic Chairs number among the most well-known designs by Charles and Ray Eames. One model has always stood out in this large family of chairs: the Rocking Armchair Rod Base (RAR). Despite compact dimensions, it offers pleasant comfort even for taller users, and is also available with a seat cushion or full upholstery. The RAR is a fully-fledged armchair, whose iconic shape and rocker base on wooden runners adds a striking accent to any living room.; Designer: Charles & Ray Eames; Manufacturer: Vitra; Model: Eames Plastic Armchair RAR, with seat upholstery; OmniClass Number: 23.40.20.14.14.11; OmniClass Title: Chairs; ProductDatasheet: https://static.vitra.com/media/asset/1040024/storage/master/download/Care%2520Instruction.pdf; Type Name: Eames Plastic Armchair RAR, with seat upholstery; URL: https://www.vitra.com/en-pl/living/product/details/eames-plastic-armchair-rar
Type - Other - Category: Furniture; AccessibilityPerformance: n/a; AssetType: Movable; Brand: Vitra; CodePerformance: n/a; Color: Various; Constituents: n/a; DurationUnit: Year; ExpectedLife: n/a; Family Name: Vitra-Chairs-Eames_Plastic_Armchair-RAR_rfa; Features: n/a; Finish: Seat shell: dyed-through polypropylene. All models are available with a seat cushion (screwed to the seat shell) or full upholstery. The fully upholstered version has moulded polyurethane foam padding covered in fabric, attached to the shell with a welted edge. Different shell and upholstery colours and various bases provide a multitude of possible combinations. Options: the Eames Plastic Chair is available as a visitor chair, dining chair, rocking chair, swivel chair or in stacking versions and with ganging brackets for row seating. Beam-mounted shells are suited for use in waiting areas. RAR base: wire base with cross struts, chrome-plated or powder-coated, solid maple runners. (RAR = Rocking Armchair Rod Base); Grade: n/a; ModelNumber: n/a; ModelReference: 44036600; Name: Eames_Plastic_Armchair-LAR; ReplacementCost: n/a; Shape: Sculptured; Size: 630x800x720 mm; SustainabilityPerformance: n/a; WarrantyDescription: n/a; WarrantyDurationLabor: n/a; WarrantyDurationParts: n/a; WarrantyDurationUnit: Year; WarrantyGuarantorLabor: n/a; WarrantyGuarantorParts: n/a
Type - Pset_ElementShading - Color: Various
Type - Pset_ManufacturerTypeInformation - ModelReference: 44036600; Manufacturer: Vitra
Type - Pset_ProductRequirements - Name: Eames_Plastic_Armchair-LAR; Category: Furniture
Type - Pset_QuantityTakeOff - Reference: Eames Plastic Armchair RAR, with seat upholstery
Pset_ManufacturerOccurrence - BarCode: n/a; SerialNumber: n/a
Constraints - Elevation from Level: 0 mm; Host: Level : Level 1; Level: Level: Level 1; Moves With Nearby Elements: no; Offset from Host: 0 mm
Construction - felt gliders basic dark for hard floor: yes; glides basic dark for carpet: no
Dimensions - Area: 1.92706 m2; Volume: 0.364916 m3
Materials and Finishes - Base color: Chrome; Colour of seat cover: Hopsak red cognac; Colour of seat shell: Poppy red; Piped seam colour: Basic Dark; Rocking Runners: Legs Golden Maple
Other - AssetIdentifier: n/a; Barcode: n/a; Family: Vitra-Chairs-Eames_Plastic_Armchair-RAR_rfa: Eames Plastic Armchair RAR, with seat upholstery; Family and Type: Vitra-Chairs-Eames_Plastic_Armchair-RAR_rfa: Eames Plastic Armchair RAR, with seat upholstery; InstallationDate: n/a; Material: Metal, Textile and Plastic; SerialNumber: n/a; TagNumber: n/a; Type: Vitra-Chairs-Eames_Plastic_Armchair-RAR_rfa: Eames Plastic Armchair RAR, with seat upholstery; Type Id: Vitra-Chairs-Eames_Plastic_Armchair-RAR_rfa: Eames Plastic Armchair RAR, with seat upholstery; WarrantyStartDate: n/a
Phasing - Phase Created: New Construction
